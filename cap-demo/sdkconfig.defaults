## edge-node/sdkconfig.defaults
```kconfig
CONFIG_ESP_WIFI_TASK_CORE_ID=0
CONFIG_LWIP_TASK_CORE_ID=0
CONFIG_BT_ENABLED=n
CONFIG_FREERTOS_HZ=1000
```
